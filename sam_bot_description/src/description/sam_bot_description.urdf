Commit message: added the orto_nav pkg for the SLAM

File: sam_bot_description/src/description/sam_bot_description.urdf (robot description, URDF)
Before this commit: robot sam_bot, 5 links, 4 joints
Joints:
- joint laser_joint: origin xyz=0  0    0.12 rpy=0  0  0 -> xyz=0.16  0    0.12 rpy=0  0  0
